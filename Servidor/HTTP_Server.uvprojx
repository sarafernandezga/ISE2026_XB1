# Keil uVision project HTTP_Server.uvprojx, settings and files
target Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HTTP_Server
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HSE_VALUE=8000000
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./: main.c HTTP_Server.c HTTP_Server_CGI.c
    Web/: Web.c
  group Web files
    ./Web/: index.htm pg_header.inc pg_footer.inc ad.cgi ad.cgx buttons.cgi buttons.cgx language.cgi lcd.cgi leds.cgi network.cgi system.cgi tcp.cgi xml_http.js home.png keil.gif logo.gif llblue.jpg pabb.gif rtc.cgi rtc.cgx
  group Documentation
    ./: Abstract.txt
  group LDC
    ./: Arial12x12.h lcd.c lcd.h
  group RTC
    ./: rtc.c rtc.h
  group SNTP
    ./: sntp.c sntp.h
  group COM
    ./: com.c com.h
  group MEM
    ./: mem.c mem.h
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:Event Recorder 1.4.0, Network:CORE 7.15.0, Network:Interface:ETH 7.15.0, Network:Service:DNS Client 7.15.0, Network:Service:SNTP Client 7.15.0, Network:Service:Web Server Compact 7.15.0, Network:Socket:TCP 7.15.0, Network:Socket:UDP 7.15.0, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, CMSIS Driver:Ethernet MAC 2.9, CMSIS Driver:Ethernet PHY:LAN8742A 1.3.0, CMSIS Driver:SPI 2.15, Device:STM32Cube Framework:Classic 1.7.9, Device:STM32Cube HAL:ADC 1.7.9, Device:STM32Cube HAL:Common 1.7.9, Device:STM32Cube HAL:Cortex 1.7.9, Device:STM32Cube HAL:DMA 1.7.9, Device:STM32Cube HAL:GPIO 1.7.9, Device:STM32Cube HAL:PWR 1.7.9, Device:STM32Cube HAL:RCC 1.7.9, Device:STM32Cube HAL:RTC 1.7.9, Device:STM32Cube HAL:SPI 1.7.9, Device:STM32Cube HAL:SRAM 1.7.9, Device:STM32Cube HAL:TIM 1.7.9, Device:STM32Cube LL:Common 1.7.9, Device:STM32Cube LL:PWR 1.7.9, Device:STM32Cube LL:RCC 1.7.9, Device:STM32Cube LL:RTC 1.7.9, Device:STM32Cube LL:UTILS 1.7.9, Device:Startup 2.6.3
